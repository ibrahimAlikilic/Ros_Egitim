Commit message: Dosyaları birbirine include etme.

File: Notlar/URDF_Dosyasi_Olusturma/xacro/test.xacro (robot description, xacro)
@@ -10,4 +10,5 @@
             </geometry>
             <origin xyz="0 0 0" rpy="0 0 0"/>
+            <material name="grey" />
         </visual>
     </link>
